<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Cubli.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\GPIOTester\GPIOTester.ewp</path>
    </project>
    <batchBuild />
</workspace>
